# Keil uVision project blink_lpc.uvproj, settings and files
target LPC (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC2105 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: blink_lpc
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: LPC2105_simulador
  c include: ../../src;../src_lpc
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source Comun
    ../../src/: main.c drv_leds.c drv_leds.h drv_tiempo.c drv_tiempo.h hal_gpio.h hal_tiempo.h board.h drv_consumo.c drv_consumo.h hal_consumo.h drv_monitor.h drv_monitor.c rt_evento_t.h rt_fifo.c rt_fifo.h ifdebug.h rt_GE.h rt_GE.c svc_alarma.c svc_alarma.h hal_ext_int.h drv_botones.c drv_botones.h hal_WDT.h random.c random.h simon.c simon.h hal_concurrencia.h
  group Dependientes
    ../src_lpc/: board_lpc.h hal_tiempo_lpc.c hal_gpio_lpc.c reserva_gpio_lpc2105.h hal_consumo_lpc.c hal_ext_int_lpc.c hal_WDT_lpc.c hal_concurrencia_lpc.c
  group Inicio
    ../src_lpc/: Startup.s
